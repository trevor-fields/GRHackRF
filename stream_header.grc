options:
  parameters:
    author: Trevor Fields
    generate_options: hb
    id: get_header
    output_language: python
    title: Get Header
  states: {}

blocks:
- name: a_header
  id: parameter
  parameters:
    label: Header Object
    value: '0'
  states: {}
- name: b_tag
  id: parameter
  parameters:
    label: Length Tag
    value: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: d_in
    l: e_out
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: d_in
    l: e_out
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: c_payload_len
    type: byte
  states: {}
- name: c_payload_len
  id: parameter
  parameters:
    label: Payload Length (Bytes)
    value: '2'
  states: {}
- name: d_in
  id: parameter
  parameters:
    hide: part
    label: Input Byte Size
    value: '8'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: a_header
    len_tag_key: b_tag
  states: {}
- name: e_out
  id: parameter
  parameters:
    hide: part
    label: Output Byte Size
    value: '1'
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: header
    type: byte
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: payload
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [blocks_repack_bits_bb_1, '0', pad_sink_1, '0']
- [blocks_repack_bits_bb_1_0, '0', pad_sink_1_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_repack_bits_bb_1_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_repack_bits_bb_1, '0']
- [pad_source_0, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
