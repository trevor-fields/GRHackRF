options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: demo_rx
    max_nouts: ''
    output_language: python
  states: {}

blocks:
- name: Bpp
  id: variable
  parameters:
    value: len(msg_str)
  states: {}
- name: QPSK
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: baseband_LO
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: Decoder Delay
    orient: Qt.Horizontal
    start: '-8'
    step: '1'
    stop: '8'
    value: '0'
  states: {}
- name: delay_0
  id: variable_qtgui_range
  parameters:
    label: Reciever Delay
    orient: Qt.Horizontal
    start: '-8'
    step: '1'
    stop: '8'
    value: '0'
  states: {}
- name: msg_str
  id: variable
  parameters:
    value: '"Hello World! \r\n"'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '25'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '20'
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1024'
    reference: '1.55'
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: |-
      Output of
      Reciever
    delay: delay
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: delay_0
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/sdr/data_points
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: Write to Terminal
    file: /dev/pts/0
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/sdr/Documents/GRHackRF/bits_recieved
    type: byte
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    comment: 2-bit Symbols into bitstream
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '1'
    len_tag_key: ''
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: Pack Bits into Bytes
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: Pack Bits into Bytes
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: ''
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    comment: |-
      Remove Tags to
      Simulate Channel
    propagate_tags: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Get 2-bit symbols
    constellation: QPSK
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: Align Data with Known Header
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.0628'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_lms_dd_equalizer_cc_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: QPSK
    mu: '.01'
    num_taps: '8'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: (0,1,3,2)
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '.062'
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: get_header_0
  id: get_header
  parameters:
    a_header: header_00
    b_tag: '"packet_len"'
    c_payload_len: Bpp+18
    d_in: '8'
    e_out: '8'
  states: {state: disabled}
- name: header_00
  id: parameter
  parameters:
    label: Header
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: baseband_LO
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1.6E3
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=1"'
    bb_gain0: '20'
    freq0: 890e6
    gain0: '30'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    freq0: 230e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: stream_source_0
  id: stream_source
  parameters:
    a_msg_str: msg_str
    b_Bpp: Bpp
    comment: |-
      Input Byte Stream with
      Random Characters
  states: {state: disabled}

connections:
- [analog_feedforward_agc_cc_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_add_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_add_xx_0_0, '0', blocks_delay_1, '0']
- [blocks_delay_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_delay_1, '0', digital_lms_dd_equalizer_cc_0, '0']
- [blocks_repack_bits_bb_1, '0', blocks_repack_bits_bb_1_0_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_file_sink_0_0, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_file_sink_1, '0']
- [blocks_repack_bits_bb_1_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', blocks_file_sink_1, '0']
- [blocks_tag_gate_0, '0', digital_constellation_modulator_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_tag_gate_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', low_pass_filter_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_add_xx_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', blocks_delay_0, '0']
- [digital_map_bb_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [get_header_0, '0', blocks_tagged_stream_mux_0, '0']
- [get_header_0, '1', blocks_tagged_stream_mux_0, '1']
- [low_pass_filter_0, '0', analog_feedforward_agc_cc_0, '0']
- [osmosdr_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [stream_source_0, '0', get_header_0, '0']

metadata:
  file_format: 1
